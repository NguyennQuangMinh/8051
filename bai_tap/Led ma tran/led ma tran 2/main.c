
// dem tu 0 -> 9

#include "main.h"
#include "C:\hoc\8051\bai_tap\Library\Delay\Delay.h"

unsigned char code Font5x7[10][7] = { {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E},		// Font cua so 0
																			{0x1F, 0x04, 0x04, 0x04, 0x14, 0x0C, 0x04},		// Font cua so 1
																			{0x1F, 0x10, 0x08, 0x04, 0x12, 0x11, 0x0E},		// Font cua so 2
																			{0x0E, 0x11, 0x02, 0x04, 0x02, 0x11, 0x0E},		// Font cua so 3
																			{0x02, 0x02, 0x02, 0x1F, 0x0A, 0x06, 0x02},		// Font cua so 4
																			{0x1F, 0x01, 0x01, 0x1F, 0x10, 0x10, 0x1F}, 	// Font cua so 5
																			{0x1F, 0x11, 0x11, 0x1F, 0x10, 0x10, 0x1F},		// Font cua so 6
																			{0x04, 0x04, 0x04, 0x04, 0x02, 0x11, 0x1F},		// Font cua so 7
																			{0x0E, 0x11, 0x1B, 0x0E, 0x11, 0x11, 0x0E},		// Font cua so 8
																			{0x1F, 0x01, 0x01, 0x1F, 0x11, 0x11, 0x1F},		// Font cua so 9
																		};
void main()
{
	unsigned int i,j,cnt;
	while(1)
	{
		for(cnt=0; cnt<10; cnt++) // dem tu 0 -> 9
		{
			for(i=0; i<143; i++) // giu so do trong vong 1 giay sau do moi dem tang do thuc hien quet led het moi lan la 1ms*7lan = 7ms => 1000ms tuong duong voi lap lai 143 lan (1000/7)
			{
				// quet led hien thi so
				for(j=0; j<7; j++)
				{
					P0 = Font5x7[cnt][j];
					P3 = 0x01<<j;
					Delay_ms(1);
					P3 = 0x00;
				}		
			}		
		}
	}
}
