# Keil uVision project lich van nien su dung ngat ngoai va ru ngu vi dieu khien.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: lich van nien su dung ngat ngoai va ru ngu vi dieu khien +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../Library/Delay/: Delay.c
    ../Library/LCD16x2_4bit/: LCD4.c
    ../Library/Lunar Calculator/: LunarCalendar.c
    ../Library/RTC DS1307/: Rtc_Ds1307.c
    ../Library/Soft I2C/: Soft_I2C.c
