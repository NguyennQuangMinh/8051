# Keil uVision project do nhiet do su dung LM35 _ phan 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: do nhiet do su dung LM35 _ phan 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../Library/ADC0804/: ADC0804.c
    ../../Library/Delay/: Delay.c
    ../../Library/LCD16x2_4bit/: LCD4.c
