# Keil uVision project ADC 3 _ ket hop voi ic ADC0808.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ADC 3 _ ket hop voi ic ADC0808 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ../../Library/ADC0808/: ADC0808.c
    ../../Library/Delay/: Delay.c
    ../../Library/LCD16x2_4bit/: LCD4.c
